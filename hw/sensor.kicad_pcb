# Repository trlsmax/lightning_trigger

File README.md:

# lightning_trigger
trigger the camera to capture lightning

sensor and filter circuit come from this [BLOG][1]

[1]:http://diy.viktak.com/2011/03/zeus-lightning-trigger-for-cameras.html

## KiCad design hw/sensor.kicad_pcb

Parts:
C1: 100n; C_0603
P1: CONN_SENSOR; Pin_Header_Straight_1x03
U1: OPT101; DIP-8__300_ELL

Connections:
unnamed: C1.1, P1.1, U1.1 (Vs)
unnamed: C1.2, P1.3, U1.3 (-V), U1.8 (Common)
unnamed: P1.2, U1.4 (FB), U1.5 (Output)

Notes on the sheet:
转危为安

Board: 2 copper layers, 18.3 x 16.3 mm, 3 parts (0 on the bottom side), 3 nets.

## KiCad design hw/lightning.kicad_pcb

Board: 2 copper layers, 32 parts (0 on the bottom side), 25 nets.

Parts:
BT1: Battery; Pin_Header_Straight_2x01
C1: 100n; C_0603
C2, C3: 47n; C_0603
C4, C5, C6: 1u; C_0603
D1: LED; LED-3MM
D2: CHARGE; LED-3MM
D3: D_Schottky_x2_KCom_KAA; SOT-23
IC1: STM8S103F3P6; TSSOP-20_4.4x6.5mm_Pitch0.65mm
J1: Shutter; JACK_ALIM
P1: USB_OTG; USB_Mini-B
Q1: Q_PMOS_GDS; sc70
R1, R3, R9: 2.2k; R_0603
R2: 47k; R_0603
R4: 27k; R_0603
R5, R6, R7, R8: 1k; R_0603
R10: 100k; R_0603
SW1: SW_PUSH
T1: SWIM; Measurement_Point_Round-SMD-Pad_Small
T2: NRST; Measurement_Point_Round-SMD-Pad_Small
U1: OPT101; DIP-8__300_ELL
U2: LM358; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: PC817; Optocoupler_SMD_HandSoldering_KPC357_LTV35x_PC357_SingleCha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
U4: LTC4054; SOT-23-5
U5: NCP1117ST33T3G; SOT-23

Connections:
/USB_VBUS: C5.2, D3.3, P1.1, Q1.1, R8.1, R10.1, U4.4
GND: BT1.2, C4.1, C5.1, C6.1, IC1.7, P1.5, P1.6, R1.2, R2.2, R5.1, R9.2, R10.2, SW1.2, U1.8, U2.4, U4.2, U5.1
unnamed: BT1.1, D3.2, Q1.3, U4.3
unnamed: C1.1, U1.3
unnamed: C2.1, C3.2, R3.2
unnamed: C2.2, IC1.2, U1.4, U1.5
unnamed: C3.1, R1.1, U2.3
unnamed: C4.2, IC1.8
unnamed: C6.2, D3.1, Q1.2, U5.3
unnamed: D1.1, R6.1
unnamed: D2.1, U4.1
unnamed: D2.2, R8.2
unnamed: IC1.3, R3.1, R4.1, U2.1
unnamed: IC1.4, T2.1
unnamed: IC1.10, R6.2
unnamed: IC1.11, R7.2
unnamed: IC1.17, U3.1
unnamed: IC1.18, T1.1
unnamed: J1.1, U3.4
unnamed: J1.3, U3.3
unnamed: R2.1, R4.2, U2.2
unnamed: R5.2, U3.2
unnamed: R7.1, SW1.1
unnamed: R9.1, U4.5
VCC: C1.2, D1.2, IC1.9, U1.1, U2.8, U5.2

## Commit log

2017-08-16 add fw and hw
2017-08-16 add captured lightning picture
2017-08-16 add picture to readme
2017-08-24 add mirror lockup auto restart
2017-08-24 add another captured lightning photo
2017-09-03 longer mirror lockup timerout
2017-09-03 use biggest value from background check
